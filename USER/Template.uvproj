# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\5110;..\HARDWARE\BSP;..\HARDWARE\CAN;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\MPU6050;..\HARDWARE\PWM;..\HARDWARE\SELECT;..\HARDWARE\TIMER;..\HARDWARE\ULTRASONIC;..\HARDWARE\LASER;..\HARDWARE\OLED;..\HARDWARE\MAGNET;..\ALGORITHM\ATTITUDE;..\ALGORITHM\FILTER;..\ALGORITHM\PID;..\ALGORITHM\SIN_COS_TABLE;..\ALGORITHM\CONTROL;..\ALGORITHM\MANIFOLD;..\ALGORITHM\MONITOR;..\ALGORITHM\TASK;..\ALGORITHM\ROUTINE;E:\MDK\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c Config.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/SELECT/: select.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ULTRASONIC/: UltraSonic.c
    ../HARDWARE/LASER/: laser.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MAGNET/: magnet.c
  group ALGORITHM
    ../ALGORITHM/PID/: PosPID.c
    ../ALGORITHM/SIN_COS_TABLE/: SinCosTABLE.c
    ../ALGORITHM/CONTROL/: control.c
    ../ALGORITHM/MANIFOLD/: manifold.c
    ../ALGORITHM/MONITOR/: monitor.c
    ../ALGORITHM/TASK/: task.c
    ../ALGORITHM/ROUTINE/: routine.c
